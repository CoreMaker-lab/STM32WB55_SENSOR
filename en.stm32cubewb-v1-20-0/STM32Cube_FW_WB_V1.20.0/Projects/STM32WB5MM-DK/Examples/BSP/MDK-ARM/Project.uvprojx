# Keil uVision project Project.uvprojx, settings and files
target STM32WB5MM-DK (6190000::V6.19::ARMCLANG)
  device: STM32WB5MMGHx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.2.1
  cpu: IRAM(0x20000000,0x00040000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: RCC_ClockConfig +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32WB5Mxx,STM32WB55xx,USE_HAL_DRIVER,USE_STM32WB5M_DK,CORE_CM4,ARM_MATH_CM4,USE_USB_FS,__DBG_ITM
  c misc: -Wno-format -Wno-header-guard -Wno-absolute-value
  c include: ../Inc;../Src/vl53l0x;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/CMSIS/Device/ST/STM32WBxx/Include;../../../../../Drivers/STM32WBxx_HAL_Driver/Inc;../../../../../Drivers/BSP/STM32WB5MM-DK;../../../../../Drivers/BSP/Components/Common;../../../../../Drivers/BSP/Components/ism330dhcx;../../../../../Drivers/BSP/Components/s25fl128s;../../../../../Utilities/LCD;../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Inc;../Inc/usb;../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../Drivers/CMSIS/DSP/Source/FilteringFunctions;../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/AUDIO/Inc;../../../../../Drivers/CMSIS/DSP/Include;../../../../../Drivers/BSP/Components/stts22h
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: stm32wb5mxx_flash_cm4.sct
  link misc: --diag_suppress L6314W
--diag_suppress 1296
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/ism330dhcx/: ism330dhcx.c ism330dhcx_reg.c
    ../../../../../Drivers/BSP/Components/s25fl128s/: s25fl128s.c
    ../../../../../Drivers/BSP/Components/ssd1315/: ssd1315.c ssd1315_reg.c
    ../../../../../Drivers/BSP/Components/stts22h/: stts22h.c stts22h_reg.c
  group Drivers/BSP/STM32WB5MM-DK
    ../../../../../Drivers/BSP/STM32WB5MM-DK/: stm32wb5mm_dk.c stm32wb5mm_dk_audio.c stm32wb5mm_dk_bus.c stm32wb5mm_dk_env_sensors.c stm32wb5mm_dk_env_sensors_ex.c stm32wb5mm_dk_lcd.c stm32wb5mm_dk_motion_sensors.c stm32wb5mm_dk_motion_sensors_ex.c stm32wb5mm_dk_qspi.c
  group Drivers/CMSIS
    ../Src/: system_stm32wbxx.c
  group Drivers/CMSIS/DSP/Source/FilteringFunctions
    ../../../../../Drivers/CMSIS/DSP/Source/FilteringFunctions/: arm_fir_decimate_init_q15.c arm_fir_decimate_q15.c
  group Drivers/STM32WBxx_HAL_Driver
    ../../../../../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal.c stm32wbxx_hal_cortex.c stm32wbxx_hal_dma.c stm32wbxx_hal_exti.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_i2c.c stm32wbxx_hal_i2c_ex.c stm32wbxx_hal_pcd.c stm32wbxx_hal_pcd_ex.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_qspi.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_sai.c stm32wbxx_hal_sai_ex.c stm32wbxx_hal_spi.c stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c stm32wbxx_hal_uart.c stm32wbxx_hal_uart_ex.c stm32wbxx_ll_usb.c
  group Example/MDK-ARM
    ./: startup_stm32wb5mxx_cm4.s
  group Example/User
    ../Src/: lcd.c led.c main.c proximity.c qspi.c record.c sensors.c stm32wbxx_it.c
    ./: Retarget.c Serial.c
  group Example/User/usb
    ../Src/usb/: usbd_audio_if.c usbd_audio_in.c usbd_conf.c usbd_desc.c
  group Example/User/vl53l0x
    ../Src/vl53l0x/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c vl53l0x_platform_log.c vl53l0x_tof.c
  group Middlewares/ST/STM32_Audio/PDM
    ../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Lib/: libPDMFilter_CM4_Keil_wc16.lib
  group Middlewares/ST/STM32_USB_Device_Library/Core
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Utilities
    ../../../../../Utilities/LCD/: stm32_lcd.c
software components: CMSIS:CORE 5.4.0
